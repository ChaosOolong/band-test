# Keil uVision project band_2_STORAGE_MSC.uvprojx, settings and files
target band_2_STORAGE_MSC (6190000::V6.19::ARMCLANG)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x2002FFFF) IROM(0x08000000-0x807FFFF) IRAM2(0x20030000-0x200323FF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32_STORAGE_SENSOR +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32WB55xx
  c include: ../Core/Inc;../STM32_WPAN/App;../USB_Device/App;../USB_Device/Target;../Drivers/STM32WBxx_HAL_Driver/Inc;../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../Utilities/lpm/tiny_lpm;../Middlewares/ST/STM32_WPAN;../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;../Middlewares/ST/STM32_WPAN/utilities;../Middlewares/ST/STM32_WPAN/ble/core;../Middlewares/ST/STM32_WPAN/ble/core/auto;../Middlewares/ST/STM32_WPAN/ble/core/template;../Middlewares/ST/STM32_WPAN/ble/svc/Inc;../Middlewares/ST/STM32_WPAN/ble/svc/Src;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../Utilities/sequencer;../Middlewares/ST/STM32_WPAN/ble;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x2400
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: bno055.c W25Q.c main.c gpio.c adc.c i2c.c ipcc.c rf.c rtc.c spi.c app_entry.c app_debug.c hw_timerserver.c stm32_lpm_if.c stm32wbxx_it.c stm32wbxx_hal_msp.c
    ../Core/Inc/: bno055.h W25Q.h
    ../USB_Device/App/: usbd_storage_if.h
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usbd_storage_if.h usb_device.c usbd_desc.c usbd_storage_if.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c p2p_server_app.c custom_stm.c custom_app.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_ll_usb.c stm32wbxx_hal_rcc.c stm32wbxx_ll_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_ll_adc.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Utilities
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../Utilities/sequencer/: stm32_seq.c
  group Middlewares/STM32_WPAN
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: tl_mbox.c hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c ble_events.c
    ../Middlewares/ST/STM32_WPAN/ble/svc/Src/: p2p_stm.c svc_ctl.c
software components: CMSIS:CORE 5.6.0
